# Keil uVision project cm68.uvproj, settings and files
target cm68 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) XRAM(0-0xFFFF) CODE(0-0x7FFF) CLOCK(24000000)
  output: cm68 +hex
  c flags: Optimize=9
  c define: NOTURNO_SLEEP_FIX
  c misc: ROM(LARGE)
  c include: src
  link misc: CODE(?CO?INITIMG(0X04FB))
  group Source
    ./src/: main.c power.c uart.c mathutil.c frame.c cluster.c hwconfig.c xram_defs.c initimg.c
  group Headers
    ./src/: cm68.h cm68_sfr.h cm68_xram.h cm68_stubs.h cm68_code_tables.h constants.h
